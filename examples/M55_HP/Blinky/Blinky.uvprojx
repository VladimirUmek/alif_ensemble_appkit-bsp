# Keil uVision project Blinky.uvprojx, settings and files
target Debug (6230000::V6.23::ARMCLANG)
  device: AE722F80F55D5LS:M55_HP Alif Semiconductor
  pack: AlifSemiconductor.Ensemble.2.0.0-dev
  cpu: IRAM(0x02000000,0x00400000) IRAM2(0x08000000,0x00280000) IROM(0x80000000,0x00580000) XRAM(0x50000000,0x00040000) XRAM2(0x50800000,0x00100000) XRAM3(0x58000000,0x00040000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ELITTLE
  output: Blinky
  AfterMake: fromelf.exe --bin Objects\Blinky.axf --output Objects\Blinky.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CMSIS_target_header=\"AppKit-E7.h\"
  c include: .\ConductorTool; .\
  memory RVCT4: ROM 0x80000000 size 0x580000
  memory RVCT6: RAM 0x50000000 size 0x40000
  memory RVCT7: RAM 0x50800000 size 0x100000
  memory RVCT8: RAM 0x58000000 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x400000
  memory RVCT10: RAM 0x8000000 size 0x280000
  scatter file: .\RTE\Device\AE722F80F55D5LS_M55_HP\M55_HP.sct
  group Source
    ./: Blinky.c
  group Board
    ./: main.c AppKit-E7.h retarget_stdio.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:Custom 1.1.0, CMSIS-Compiler:STDIN:Custom 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, CMSIS Driver:GPIO 1.0.0, CMSIS Driver:USART 1.3.0, Device:Conductor Tool support 1.3.0, Device:Retarget IO:STDERR 1.3.0, Device:Retarget IO:STDIN 1.3.0, Device:Retarget IO:STDOUT 1.3.0, Device:SOC Peripherals:PINCONF 1.3.0, Device:Startup 1.3.0, CMSIS Driver:VIO:Board 1.0.0
